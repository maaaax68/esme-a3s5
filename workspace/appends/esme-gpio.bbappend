inherit externalsrc
EXTERNALSRC = "/home/jourdes/w/src/esme-pwm0-gpio12"
EXTERNALSRC_BUILD = "/home/jourdes/w/src/esme-pwm0-gpio12"

# initial_rev .: 3e6f9504cef5f06fd26b69b70d7a05825c667939
